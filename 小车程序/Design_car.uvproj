# Keil uVision project Design_car.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Design_car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Config.c L298N.C main.c PWM.c DS1302.c L298N.h PWM.h DS1302.h 超声波.c 问题.c Red_Line.c
