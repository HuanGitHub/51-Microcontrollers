# Keil uVision project 智能小车.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Config.c Controller.c L298N.c LCD.c Main.c PWM.c Steering_engine.c Ultrasound.c 问题
